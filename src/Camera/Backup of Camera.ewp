# IAR project Backup of Camera.ewp, settings and files
configuration STM32_PFE (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Backup of Camera.hex
  ILINK.IlinkOutputFile: Backup of Camera.out
configuration STM32-P407-Camera (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: Project.srec
  group board
    ../../board/: iar_stm32f217ze_sk.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
  group CMSIS
    ./: system_stm32f2xx.c
  group modules
    ../../modules/: drv_glcd.c E700_Camera.c ExternalSRAM.c glcd_ll.c
  group STM32F2xx_StdPeriph_Driver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group User
    ./: main.c stm32f2xx_it.c Terminal_9_12x6.c
